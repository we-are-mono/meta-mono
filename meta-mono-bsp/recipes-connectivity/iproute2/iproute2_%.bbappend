# NXP ASK extensions for EtherIP and 4RD tunnel support

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://01-nxp-ask-etherip-4rd.patch"
