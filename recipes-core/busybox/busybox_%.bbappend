FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://devmem.cfg \
            file://dd-conv.cfg"
