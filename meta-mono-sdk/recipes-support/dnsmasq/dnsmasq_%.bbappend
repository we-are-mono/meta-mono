# Disable dnsmasq by default - users enable when needed
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
