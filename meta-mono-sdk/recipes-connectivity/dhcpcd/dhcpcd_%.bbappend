# Disable dhcpcd by default - users enable when needed
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
