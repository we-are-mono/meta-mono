RDEPENDS:${PN}:remove = " \
    watchdog \
"
